# Keil uVision project usb_host_ch559.uvproj, settings and files
target usb_host (MCS-51)
  device: SST89x58RD SST
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x7FFF) CLOCK(40000000)
  output: usb_host_ch559 +hex
  c flags: SizeSpeed=1
  c define: xDEBUG
  link misc: removeunused
  group Source
    ./: GPIO.c Uart.c System.c Main.c Task.c Packet.c RecvBuffer.c Timer2.c UsbHid.c UsbHost.c CH559.c Ps2Keyboard.c Ps2Mouse.c KeyboardLed.c ParseHidData.c IpPs2Keyboard.c IpPs2Mouse.c ParseDescriptor.c
  group Header
    ./: CH559.h GPIO.h Gpio_map.h Type.h Uart.h UsbDef.h System.h Task.h PinDefine.h mcu.h Packet.h RecvBuffer.h Timer2.h Trace.h UsbHid.h UsbHost.h Ps2Keyboard.h Ps2Mouse.h KeyboardLed.h ProcessPs2Data.h ParseHidData.h ParseDescriptor.h
